# Keil uVision project k20dx128_bootloader.uvproj, settings and files
target k20dx128_bootloader (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_bootloader.bin" "#L"
  c flags: Optim=3
  c define: __RTX, TARGET_MK20DX, CPU_MK20DX128VFM5
  c misc: --diag_suppress=2532
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\..\shared\cmsis\TARGET_Freescale\include;..\..\..\shared\flash_algo\TARGET_Freescale
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
  group Common
    ../../Common/src/: flash_svc.c main.c RTX_Config.c SVC_Table.s usb_config.c usbd_user_msc.c version.c
  group HAL
    ../../hal/TARGET_Freescale/TARGET_MK20DX/: gpio.c read_uid.c usbd_MK20D5.c vector_table.c flash_hal.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group flash
    ../../../shared/flash_algo/TARGET_Freescale/flash/: flash.h
    ../../../shared/flash_algo/TARGET_Freescale/flash/src/: SSD_FTFx_Common.h fsl_flash_features.h flash_features.h flash_densities.h flash_command_sequence.c flash_densities_k_series.c flash_erase.c flash_erase_all.c flash_init.c flash_program.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c
