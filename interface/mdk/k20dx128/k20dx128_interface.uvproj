# Keil uVision project k20dx128_interface.uvproj, settings and files
target k20dx128_kl25z_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx_kl25z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3
  c define: TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_FRDM_KL25Z, INTERFACE_GEN_32KHZ
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL25Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c serial.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: DAP_config.h gpio.c read_uid.c uart.c usbd_MK20D5.c usb_buf.h
  group HAL-Target
    ../../target/hal/DBG_Freescale/common/: target_reset_Kseries.c target_reset_Lseries.c target_flash_common.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target k20dx128_kl25z_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl25z_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_kl25z_if_openSDA.S19" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_FRDM_KL25Z, INTERFACE_GEN_32KHZ
  c include: ..\..\Common\inc;..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\interface\cmsis;..\..\target\hal\DBG_Freescale\DBG_KL25Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5_openSDA_bootloader.sct
target k20dx128_kl25z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl25z_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_kl25z_if_mbed.bin" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_FRDM_KL25Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5_mbed_bootloader.sct
target k20dx128_twr_kl25z_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx_twr_kl25z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3
  c define: TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_TWR_KL25Z48M, INTERFACE_POWER_EN
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_twr_kl25z_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_twr_kl25z_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_twr_kl25z_if_openSDA.S19" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_TWR_KL25Z48M, INTERFACE_POWER_EN
  c misc: -DKL25Z
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_twr_kl25z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_twr_kl25z_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_twr_kl25z_if_mbed.bin" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL25Z, BOARD_TWR_KL25Z48M, INTERFACE_POWER_EN
  c misc: -DKL25Z
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k20dx_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k20dx_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, DBG_K20D50M, BOARD_FRDM_K20D50M
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_K20D50M;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k20dx_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k20d50_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_k20d50_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_K20D50M, BOARD_FRDM_K20D50M
  c misc: -DK20D50M
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k20dx_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k20d50_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_k20d50_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_K20D50M, BOARD_FRDM_K20D50M
  c misc: -DK20D50M
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl05z_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl05z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=1
  c define: TARGET_MK20D5, __RTX, DBG_KL05Z, BOARD_FRDM_KL05Z, INTERFACE_GEN_32KHZ, USE_USB_EJECT_INSERT
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL05Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl05z_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl05z_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_kl05z_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_KL05Z, BOARD_FRDM_KL05Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl05z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl05z_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_kl05z_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL05Z, BOARD_FRDM_KL05Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl46z_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl46z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, DBG_KL46Z, BOARD_FRDM_KL46Z, INTERFACE_GEN_32KHZ
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL46Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl46z_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl46z_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_kl46z_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_KL46Z, BOARD_FRDM_KL46Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl46z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl46z_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_kl46z_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL46Z, BOARD_FRDM_KL46Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k64f_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k64f_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, DBG_K64F, BOARD_FRDM_K64F, INTERFACE_POWER_EN
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_K64F;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k64f_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k64f_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_k64f_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_K64F, BOARD_FRDM_K64F, INTERFACE_POWER_EN
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k64f_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k64f_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_k64f_if_mbed.bin" "#L"
  c flags: Optim=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_K64F, BOARD_FRDM_K64F, INTERFACE_POWER_EN
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl02z_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl02z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, DBG_KL02Z, BOARD_FRDM_KL02Z, INTERFACE_GEN_32KHZ
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL02Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl02z_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl02z_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_kl02z_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_KL02Z, BOARD_FRDM_KL02Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl02z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl02z_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_kl02z_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL02Z, BOARD_FRDM_KL02Z, INTERFACE_GEN_32KHZ
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl26z_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx_kl26z_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3
  c define: TARGET_MK20D5, __RTX, DBG_KL26Z, BOARD_FRDM_KL26Z, INTERFACE_GEN_32KHZ
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL26Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl26z_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl26z_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_kl26z_if_openSDA.S19" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_KL26Z, BOARD_FRDM_KL26Z, INTERFACE_GEN_32KHZ
  c misc: -DKL25Z
  c include: ..\..\Common\inc;..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\interface\cmsis;..\..\target\hal\DBG_Freescale\DBG_KL26Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_kl26z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl26z_if_mbed
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_kl26z_if_mbed.bin" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL26Z, BOARD_FRDM_KL26Z, INTERFACE_GEN_32KHZ
  c misc: -DKL25Z
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k22f_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k22f_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, DBG_K22F, BOARD_FRDM_K22F, INTERFACE_POWER_EN
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_K22F;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k22f_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k22f_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_k22f_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_K22F, BOARD_FRDM_K22F, INTERFACE_POWER_EN
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k22f_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k22f_if_mbed_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_k22f_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_K22F, BOARD_FRDM_K22F, INTERFACE_POWER_EN
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k24f256_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k24f256_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, DBG_K24F256, BOARD_FRDM_K22F, INTERFACE_POWER_EN
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_K24F256;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k24f256_openSDA_bootloader (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k24f256_if_openSDA
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\k20dx128_k24f_if_openSDA.S19" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_K24F256, BOARD_FRDM_K22F, INTERFACE_POWER_EN
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
target k20dx128_k24f256_mbed_bootloader (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_k24f256_if_mbed_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_k24f_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_K24F256, BOARD_FRDM_K22F, INTERFACE_POWER_EN
  c include: as above
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: as above
