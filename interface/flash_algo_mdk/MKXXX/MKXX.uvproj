# Keil uVision project MKXX.uvproj, settings and files
target MK20DX128_Pflash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK20DX128
  c flags: Optim=4
  c define: CPU_MK20DX128VLH5, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: .;..\..\..\shared\cmsis\TARGET_Freescale\include;..\..\..\shared\cmsis;..\..\..\shared\flash_algo\TARGET_Freescale
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: flash_algo.c
  group flash
    ../../../shared/flash_algo/TARGET_Freescale/flash/: flash.h
    ../../../shared/flash_algo/TARGET_Freescale/flash/src/: flash_densities_k_series.c flash_densities_kl_series.c flash_erase.c flash_erase_all.c flash_init.c flash_program.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c flash_command_sequence.c SSD_FTFx_Common.h fsl_flash_features.h flash_features.h flash_densities.h flash_get_property.c
target MK64FN1M0_Pflash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK64FN1M0
  c flags: Optim=4
  c define: CPU_MK64FN1M0VMD12, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu --c99
  c include: as above
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKL02Z32_Pflash (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: MKL05Z32
  c flags: Optim=4
  c define: CPU_MKL02Z32VFM4, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKL05Z32_Pflash (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: MKL02Z32
  c flags: Optim=4
  c define: CPU_MKL05Z32VLF4, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKL25Z128_Pflash (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: MKL25Z128
  c flags: Optim=4
  c define: CPU_MKL25Z128VLK4, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKL26Z128_Pflash (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: MKL26Z128
  c flags: Optim=4
  c define: CPU_MKL25Z128VLK4, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKL46Z256_Pflash (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: MKL46Z256
  c flags: Optim=4
  c define: CPU_MKL46Z256VMC4, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MK22F51212_Pflash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK22F51212
  c flags: uC99=1
  c define: CPU_MK22FN512VLL12, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MK24F256_Pflash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK24F256
  c flags: uC99=1
  c define: CPU_MK24FN256VDC12, __NO_EMBEDDED_ASM
  c misc: --diag_suppress=1 --gnu
  c include: as above
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
